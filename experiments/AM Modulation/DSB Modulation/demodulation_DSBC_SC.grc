options:
  parameters:
    author: Ricardo Alexandre
    generate_options: qt_gui
    id: demodulation_DSBC_SC
    output_language: python
    title: Demodulação DSB-SC
  states: {}

blocks:
- name: cutoff_frequency
  id: variable_qtgui_range
  parameters:
    start: 1e3
    step: '500'
    stop: 23.5e3
    value: 10e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: variable_constant
  id: variable_qtgui_range
  parameters:
    start: '0.5'
    step: '0.5'
    stop: '10'
    value: '1'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: variable_constant
    type: float
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: 20e3
    interp: '1'
    low_cutoff_freq: '200'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: 0.1*10e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_throttle2_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: D:\Documentos\Faculdade\IC_Radios_Cognitivos\Sinal_e_Audio_do_GNURadio\AM_Signal
    repeat: 'True'
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_frequency
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: cutoff_frequency*0.15
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: float
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    label1: Audio source
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '4'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: fff
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', blocks_multiply_xx_1_0, '2']
- [analog_sig_source_x_1_0, '0', blocks_multiply_xx_1_0, '1']
- [blocks_multiply_xx_1_0, '0', low_pass_filter_1, '0']
- [blocks_multiply_xx_1_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_1_0, '0', audio_sink_0, '0']
- [blocks_throttle2_1_0, '0', qtgui_freq_sink_x_2, '0']
- [blocks_throttle2_1_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_xx_1_0, '0']
- [low_pass_filter_1, '0', blocks_throttle2_1_0, '0']
- [low_pass_filter_1, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle2_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
